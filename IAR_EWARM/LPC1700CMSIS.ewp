# IAR project LPC1700CMSIS.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __RAM_MODE__=0; __BUILD_WITH_EXAMPLE__=1
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..; ..\Drivers\include; ..\Drivers\source; ..\Core\CM3\DeviceSupport\NXP\LPC17xx\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LPC1700CMSIS.hex
  ILINK.IlinkOutputFile: LPC1700CMSIS.out
configuration RAM (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: UART.srec
configuration Flash100 (ARM, debug)
  as the first configuration, except:
  group CMSIS-CM3
    ../Core/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
  group Drivers
    ../Drivers/source/: debug_frmwrk.c lpc17xx_adc.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_exti.c lpc17xx_gpdma.c lpc17xx_gpio.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_libcfg_default.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c
  group Main
    ../: Command.c crypto.c crypto.h Defines.h Flash.c Flash.h i2c.c Init.c main.c Modem.c Spi.c Timer.c Uart.c
  group Startup
    ../Core/CM3/DeviceSupport/NXP/LPC17xx/startup/iar/: startup_LPC17xx.s
